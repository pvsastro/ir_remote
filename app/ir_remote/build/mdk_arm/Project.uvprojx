# Keil uVision project Project.uvprojx, settings and files
target ir_remote (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ir_remote
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO
  c misc: --C99
  c include: ..\..\app;..\..\board\stm32f4_discovery;..\..\..\..\lib\config;..\..\..\..\hal\stm32f4xx;..\..\..\..\hal\stm32f4xx\STM32F4xx_HAL_Driver\Inc;..\..\..\..\lib\buffer;..\..\..\..\lib\common;..\..\..\..\board\stm32f4_discovery\CMSIS\Driver;..\..\..\..\board\stm32f4_discovery;..\..\..\..\lib\gpio;..\..\..\..\lib\list;..\..\..\..\lib\mm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group startup
    ./: startup_stm32f407xx.s
  group drivers
    ../../../../hal/stm32f4xx/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c_ex.c
  group app
    ../../app/: ir_remote.c
  group board
    ../../../../board/stm32f4_discovery/: stm32f4_discovery.c
    ../../board/stm32f4_discovery/: system_stm32f4xx.c stm32f4xx_bsp.c
  group lib
    ../../../../lib/buffer/: buffer.c
    ../../../../lib/common/: new.c
    ../../../../lib/gpio/: gpio.c
    ../../../../lib/list/: list.c
    ../../../../lib/mm/: mm.c
software components: CMSIS:CORE 4.1.0
